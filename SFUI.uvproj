# Keil uVision project SFUI.uvproj, settings and files
target SFUI (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: SFUI
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PLL.c LCD.s UIMain.c Menu.c
  group Environment
    ./: Ground.c Environment.c
  group Entities
    ./: Camera.c Entity.c Player.c Projectile.c Enemy.c
  group Render
    ./: Print.s ST7735.c Render.c GraphicsBuffer.c
  group Math
    ./: Math2.c vec3f.c Matrix4f.c vec4f.h vec4f.c VectorMath.c vec2f.c Quaternion.c Random.s
  group Peripherals
    ./: IO.c Sound.c
  group UI
    ./: UART.c FiFo.c Menu2.c assets.c
  group Headers
    ./: Matrix4f.h Matrix3f.h vec3f.h assets.h Camera.h Enemy.h Entity.h Environment.h FiFo.h GraphicsBuffer.h Ground.h IO.h LCD.h Math2.h Player.h PLL.h print.h Projectile.h Quaternion.h Render.h Sound.h ST7735.h TExaS.h Timer0.h Timer1.h tm4c123gh6pm.h UART.h UI.h vec2f.h vec4f.h VectorMath.h Menu.h
