# Keil uVision project StarFox.uvproj, settings and files
target Star Fox (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Star Fox
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PLL.c LCD.s StarFoxmain.c
  group Environment
    ./: Ground.c Environment.c
  group Entities
    ./: Camera.c Entity.c Player.c Projectile.c Enemy.c
  group Render
    ./: Print.s ST7735.c Render.c GraphicsBuffer.c
  group Math
    ./: vec3f.h Matrix3f.h Matrix4f.h Math2.c vec3f.c Matrix4f.c vec4f.h vec4f.c VectorMath.c vec2f.c Quaternion.c Random.s
  group Peripherals
    ./: IO.c Sound.c
  group UI
    ./: UI.c UART.c FiFo.c
